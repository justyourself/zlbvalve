# IAR project Backup of Project.ewp, settings and files
configuration STM8S105 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: vssver.scc
  group Include Files
    ../inc/: stm8s_conf.h stm8s_it.h
  group Source Files
    ../src/: main.c stm8s_it.c
  group STM8S_StdPeriph_Lib/inc
    ../../../Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_gpio.h stm8s_tim2.h
  group STM8S_StdPeriph_Lib/src
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_gpio.c stm8s_tim2.c
